// FontData.cpp - 字模数据定义
#include "FontData.h"

// 数字字模 (5x7像素)
const uint8_t DIGIT_FONT[10][5] = {
    {0x3E, 0x7F, 0x41, 0x7F, 0x3E}, // 0
    {0x00, 0x42, 0x7F, 0x40, 0x00}, // 1
    {0x62, 0x71, 0x59, 0x4F, 0x46}, // 2
    {0x22, 0x49, 0x49, 0x7F, 0x36}, // 3
    {0x0F, 0x10, 0x10, 0x7F, 0x10}, // 4
    {0x27, 0x4F, 0x49, 0x79, 0x31}, // 5
    {0x3E, 0x7F, 0x49, 0x79, 0x30}, // 6
    {0x01, 0x71, 0x0D, 0x03, 0x01}, // 7
    {0x36, 0x7F, 0x49, 0x7F, 0x36}, // 8
    {0x06, 0x4F, 0x49, 0x7F, 0x3E}  // 9
};

// 大写字母字模 (5x7像素)
const uint8_t LETTER_FONT[26][5] = {
    {0x7F, 0x09, 0x09, 0x09, 0x7F}, // A
    {0x7F, 0x49, 0x49, 0x49, 0x36}, // B
    {0x3E, 0x41, 0x41, 0x41, 0x22}, // C
    {0x7F, 0x41, 0x41, 0x41, 0x3E}, // D
    {0x7F, 0x49, 0x49, 0x49, 0x41}, // E
    {0x7F, 0x09, 0x09, 0x09, 0x01}, // F
    {0x3E, 0x41, 0x49, 0x49, 0x3A}, // G
    {0x7F, 0x08, 0x08, 0x08, 0x7F}, // H
    {0x00, 0x41, 0x7F, 0x41, 0x00}, // I
    {0x20, 0x40, 0x40, 0x40, 0x3F}, // J
    {0x7F, 0x08, 0x14, 0x22, 0x41}, // K
    {0x7F, 0x40, 0x40, 0x40, 0x40}, // L
    {0x7F, 0x02, 0x04, 0x02, 0x7F}, // M
    {0x7F, 0x02, 0x04, 0x08, 0x7F}, // N
    {0x3E, 0x41, 0x41, 0x41, 0x3E}, // O
    {0x7F, 0x09, 0x09, 0x09, 0x06}, // P
    {0x3E, 0x41, 0x51, 0x21, 0x5E}, // Q
    {0x7F, 0x09, 0x19, 0x29, 0x46}, // R
    {0x26, 0x49, 0x49, 0x49, 0x32}, // S
    {0x01, 0x01, 0x7F, 0x01, 0x01}, // T
    {0x3F, 0x40, 0x40, 0x40, 0x3F}, // U
    {0x0F, 0x30, 0x40, 0x30, 0x0F}, // V
    {0x7F, 0x20, 0x18, 0x20, 0x7F}, // W
    {0x63, 0x14, 0x08, 0x14, 0x63}, // X
    {0x07, 0x08, 0x70, 0x08, 0x07}, // Y
    {0x61, 0x51, 0x49, 0x45, 0x43}  // Z
};

// 小写字母字模 (5x7像素)
const uint8_t LOWERCASE_FONT[26][5] = {
    {0x20, 0x54, 0x54, 0x54, 0x78}, // a
    {0x7F, 0x48, 0x44, 0x44, 0x38}, // b
    {0x38, 0x44, 0x44, 0x44, 0x20}, // c
    {0x38, 0x44, 0x44, 0x48, 0x7F}, // d
    {0x38, 0x54, 0x54, 0x54, 0x18}, // e
    {0x08, 0x7E, 0x09, 0x01, 0x02}, // f
    {0x0C, 0x52, 0x52, 0x52, 0x3E}, // g
    {0x7F, 0x08, 0x04, 0x04, 0x78}, // h
    {0x00, 0x44, 0x7D, 0x40, 0x00}, // i
    {0x20, 0x40, 0x44, 0x3D, 0x00}, // j
    {0x7F, 0x10, 0x28, 0x44, 0x00}, // k
    {0x00, 0x41, 0x7F, 0x40, 0x00}, // l
    {0x7C, 0x04, 0x18, 0x04, 0x78}, // m
    {0x7C, 0x08, 0x04, 0x04, 0x78}, // n
    {0x38, 0x44, 0x44, 0x44, 0x38}, // o
    {0x7C, 0x14, 0x14, 0x14, 0x08}, // p
    {0x08, 0x14, 0x14, 0x18, 0x7C}, // q
    {0x7C, 0x08, 0x04, 0x04, 0x08}, // r
    {0x48, 0x54, 0x54, 0x54, 0x20}, // s
    {0x04, 0x3F, 0x44, 0x40, 0x20}, // t
    {0x3C, 0x40, 0x40, 0x20, 0x7C}, // u
    {0x1C, 0x20, 0x40, 0x20, 0x1C}, // v
    {0x3C, 0x40, 0x30, 0x40, 0x3C}, // w
    {0x44, 0x28, 0x10, 0x28, 0x44}, // x
    {0x0C, 0x50, 0x50, 0x50, 0x3C}, // y
    {0x44, 0x64, 0x54, 0x4C, 0x44}  // z
};

// 标点符号字模 (统一为1列宽度，组合成二维数组)
const uint8_t PUNCTUATION_FONT[6][1] = {
    {0x14},     // 0: 冒号 (1x7)
    {0x5F},     // 1: 感叹号 (1x7)
    {0x06},     // 2: 单引号 (1x7)
    {0x40},     // 3: 句点 (1x7)
    {0x40},     // 4: 点 (1x7) - 与句点相同
    {0x00}      // 5: 空格 (1x7)
};

// 标点符号映射表
const PunctuationMap PUNCTUATION_MAP[] = {
    {':',  PUNCT_COLON_INDEX,         1},
    {'!',  PUNCT_EXCLAMATION_INDEX,   1},
    {'\'', PUNCT_SINGLE_QUOTE_INDEX,  1},
    {'.',  PUNCT_PERIOD_INDEX,        1},
    {' ',  PUNCT_SPACE_INDEX,         1}
};

const uint8_t PUNCTUATION_MAP_COUNT = sizeof(PUNCTUATION_MAP) / sizeof(PunctuationMap);

// 获取字符宽度
uint8_t getCharWidth(char c) {
    if (c >= '0' && c <= '9') return 5;     // 数字宽度
    if (c >= 'A' && c <= 'Z') return 5;     // 大写字母宽度
    if (c >= 'a' && c <= 'z') return 5;     // 小写字母宽度
    
    // 查找标点符号宽度
    for (uint8_t i = 0; i < PUNCTUATION_MAP_COUNT; i++) {
        if (PUNCTUATION_MAP[i].character == c) {
            return PUNCTUATION_MAP[i].width;
        }
    }
    
    return 5;                               // 默认宽度
}

// 获取字符字模数据
const uint8_t* getCharFontData(char c) {
    if (c >= '0' && c <= '9') {
        return DIGIT_FONT[c - '0'];
    } else if (c >= 'A' && c <= 'Z') {
        return LETTER_FONT[c - 'A'];
    } else if (c >= 'a' && c <= 'z') {
        return LOWERCASE_FONT[c - 'a'];
    }
    
    // 查找标点符号字模
    for (uint8_t i = 0; i < PUNCTUATION_MAP_COUNT; i++) {
        if (PUNCTUATION_MAP[i].character == c) {
            return PUNCTUATION_FONT[PUNCTUATION_MAP[i].fontIndex];
        }
    }
    
    return nullptr; // 未知字符
}

/**
 * 生成单列垂直柱状图字模
 * @param num 点亮像素数量（0-8）
 * @return 对应字模字节
 */
byte generateVerticalBar(int num, LightDirection direction = d_up) {
  num = constrain(num, 0, 8);
  
  if(direction == d_up) {
    // 从底部向上点亮
    return (num == 0) ? 0 : (1 << num) - 1;
  } else {
    // 从顶部向下点亮
    return (num == 0) ? 0 : (0xFF << (8 - num));
  }
}